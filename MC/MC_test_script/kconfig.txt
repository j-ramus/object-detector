## MC/MC_test_script/kconfig.txt
```kconfig
mainmenu "Script Select"

    config MESSAGE
        string "Display"
        default "GPIO is active"
```
